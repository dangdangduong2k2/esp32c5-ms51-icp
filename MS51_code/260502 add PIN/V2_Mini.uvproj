# Keil uVision project V2_Mini.uvproj, settings and files
target V2_Mini (MCS-51)
  device: MS51FC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: V2_Mini +hex
  c flags: Optimize=8
  c define: FOSC_160000
  c include: .\library
  link misc: CODE(0x0000-0x6EFF)
  group Source
    ./: main.c
